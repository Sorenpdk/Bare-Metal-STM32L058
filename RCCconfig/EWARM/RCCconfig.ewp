# IAR project RCCconfig.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\soren\Desktop\Bare-Metal-STM32L058-main\RCCconfig\EWARM; C:\Users\soren\Desktop\Bare-Metal-STM32L058-main\RCCconfig\CMSIS; C:\Users\soren\Desktop\Bare-Metal-STM32L058-main\RCCconfig\Inc; C:\Users\soren\Desktop\Bare-Metal-STM32L058-main\RCCconfig\Src; C:\Users\soren\Desktop\Bare-Metal-STM32L058-main\RCCconfig\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme.txt
  group CMSIS
    ../CMSIS/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group Inc
    ../Inc/: stm32l053xx.h stm32l0xx.h system_stm32l0xx.h
  group Src
    ../Src/: system_stm32l0xx.c
  group User
    ../User/: main.c
