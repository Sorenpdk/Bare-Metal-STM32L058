<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\ADC\EWARM\ADC.ewp</path>
    </project>
    <batchBuild />
</workspace>
