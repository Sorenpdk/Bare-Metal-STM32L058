<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\3_TimerPWM\EWARM\PWM.ewp</path>
    </project>
    <batchBuild />
</workspace>
