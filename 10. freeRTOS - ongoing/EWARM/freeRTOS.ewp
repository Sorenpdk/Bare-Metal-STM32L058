# IAR project freeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Inc; ..\CMSIS; ..\User; ..\Src; ..\FreeRTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: freeRTOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group EWARM
    ./: startup_stm32l053xx.s
  group FreeRTOS
    ../FreeRTOS/: atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOSConfig.h heap_2.c list.c list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portasm.s portmacro.h projdefs.h queue.c queue.h ReadMe.url semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h task.h tasks.c timers.c timers.h
  group Inc
    ../Inc/: customclock.h customgpio.h customuart.h stm32l053xx.h stm32l0xx.h stm32l0xx_it.h system_stm32l0xx.h
  group Src
    ../Src/: customclock.c customgpio.c customuart.c stm32l0xx_it.c system_stm32l0xx.c
  group User
    ../User/: main.c
