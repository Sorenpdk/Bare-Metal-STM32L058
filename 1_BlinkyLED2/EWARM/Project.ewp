# IAR project Project.ewp, settings and files
configuration STM32L053R8_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Inc; ..\CMSIS; ..\User; ..\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../CMSIS/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group Doc
    ../: Readme.txt
  group Inc
    ../Inc/: stm32l053xx.h stm32l0xx.h stm32l0xx_it.h system_stm32l0xx.h
  group Src
    ../Src/: stm32l0xx_it.c
  group User
    ../User/: main.c
