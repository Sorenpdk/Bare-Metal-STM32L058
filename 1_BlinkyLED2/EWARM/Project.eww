<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\2_CLKConfig\EWARM\CLKConfig.ewp</path>
    </project>
    <batchBuild />
</workspace>
